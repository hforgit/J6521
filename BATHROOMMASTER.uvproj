# Keil uVision project BATHROOMMASTER.uvproj, settings and files
target SC92F7463B (MCS-51)
  device: SC92F7463B SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0x2FF) CLOCK(24000000)
  output: BATHROOMMASTER +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\01_APL;.\02_FML;.\03_HAL;.\04_SYS
  group Default
    ./: main.c STARTUP.A51
  group APL
    ./01_APL/: xy_apl_logic.c
  group FML
    ./02_FML/: xy_fml_buzzer.c xy_fml_ctrl.c xy_fml_display.c xy_fml_motor.c xy_fml_relay.c xy_fml_test.c xy_fml_touch.c
  group HAL
    ./03_HAL/: xy_hal_isr.c xy_hal_port.c xy_hal_serial.c xy_hal_timer.c
  group SYS
    ./04_SYS/: xy_sys_variable.c
